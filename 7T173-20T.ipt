# Autodesk Inventor part: 7T173-20T
## iProperties
Created: 2008-02
Part Number: 7T173-20T
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
